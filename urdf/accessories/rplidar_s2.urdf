Commit message: modified lidar file to visualize in gz

File: urdf/accessories/rplidar_s2.urdf (robot description, URDF)
Before this commit: robot rplidar_s2, 1 links, 1 joints
Links:
- link lidar_link: geometry collision cylinder length=0.02 radius=0.02; visual cylinder length=0.02 radius=0.02
